# Repository mithro/pmod-rgmii

## KiCad design SP6N02RTL8211EGigabitEthernetExpansionModule.kicad_pcb

Parts:
C1: 4.7uF
C2, C3, C8, C9, C13, C14, C15, C16, C21, C22, C23, C24, C25, C26: 100nF
C4: 1uF
C5, C6, C7, C10, C11, C12: 4.7uF
C17, C18: 12pF
C19: 27pF
C20: 0.1uF
C27: 100nF; SM0805
GS1: GS2
J1: RJ45(HFJ11-1GO1ERL)
L1, L2, L3: INDUCTOR
P1: HIROSE_120PIN
R1: 1K
R2, R6, R8, R9, R10, R11, R12, R13, R21: 0R
R4: 39K
R5: 27K
R14, R15, R16, R17, R18, R20, R26, R28, R29: 4.7K
R19: 1.5K
R22: 2.49K
R23, R24: 10K
R25, R27: 390R
R30, R31: 330R
U1: MCP1825
U2: 24AA02E48; SO8
U3: RTL8211E-VB
X1: 50MHz

Connections:
/AVDD3V3: C11.1, C13.1, C15.1, L2.2, U3.6 (AVDD33), U3.41 (AVDD33)
/ETH_INT_B: P1.52, U3.20 (INTB)
/ETH_MDC: P1.53, U3.30 (MDC)
/ETH_MDIO: P1.55, R19.2, U3.31 (MDIO)
/ETH_RESET_B: C20.1, P1.47, R16.1, U3.29 (PHYRSTB)
/ETH_RXCLK: P1.28, R13.1
/ETH_RXCTL: P1.101, R12.1
/ETH_RXD0: P1.99, R8.1
/ETH_RXD1: P1.98, R9.1
/ETH_RXD2: P1.96, R10.1
/ETH_RXD3: P1.95, R11.1
/ETH_TXCLK: P1.29, U3.22 (TXC)
/ETH_TXCTL: P1.46, U3.27 (TXCTL)
/ETH_TXD0: P1.31, U3.23 (TXD0)
/ETH_TXD1: P1.32, U3.24 (TXD1)
/ETH_TXD2: P1.34, U3.25 (TXD2)
/ETH_TXD3: P1.35, U3.26 (TXD3)
/ETH_VCC1V0: C10.1, C24.1, C25.1, C26.1, L1.2, R21.2, U3.3 (AVDD10), U3.9 (AVDD10), U3.40 (AVDD10)
/ETH_VCC3V3: C2.1, C3.1, C12.1, C14.1, C16.1, C23.1, L3.2, R14.1, R17.1, R18.1, R19.1, R20.1, U3.15 (DVDD33), U3.21 (DVDD33), U3.37 (DVDD33)
/FPGA_CLK: P1.83, R2.1
/LED0: J1.12 (LED-), R25.2
/LED1: J1.13 (LED+), R27.2
/MAC_SCL: P1.105, R23.1, U2.6 (SCL)
/MAC_SDA: P1.104, R24.1, U2.5 (SDA)
/SYSCLK: P1.84, U3.46 (CLK125)
/VCC1V0: C4.1, C7.1, L1.1, R4.2, U1.4 (VOUT)
/VCC3V3: C1.1, C5.1, C6.1, C8.1, C9.1, C27.1, GS1.2 (G2), L2.1, L3.1, P1.118, P1.119, R1.2, R16.2, R23.2, R24.2, R26.2, R29.2, R31.2, U1.2 (VIN), U2.8 (VCC)
/XTAL1_50MHZ: C18.1, R2.2, U3.42 (CKXTAL1), X1.2
/XTAL2_50MHZ: C17.1, R6.2, U3.43 (CKXTAL2), X1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, J1.0 (S1), J1.10 (GND), P1.1, P1.4, P1.7, P1.10, P1.15, P1.18, P1.21, P1.24, P1.27, P1.30, P1.33, P1.36, P1.39, P1.42, P1.45, P1.48, P1.51, P1.54, P1.57, P1.60, P1.61, P1.64, P1.67, P1.70, P1.73, P1.76, P1.79, P1.82, P1.85, P1.88, P1.91, P1.94, P1.97, P1.100, P1.103, P1.106, P1.107, P1.108, P1.109, P1.112, P1.115, P1.120, R5.1, R6.1, R15.2, R22.2, R28.2, R30.2, U1.3 (GND), U1.6, U2.1 (A0)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
unnamed: R29.1, U3.32 (LED2/RXDLY)
unnamed: J1.6, U3.5 (MDI[1]-)
unnamed: J1.4, U3.7 (MDI[2]+)
unnamed: J1.5, U3.8 (MDI[2]-)
unnamed: J1.7, U3.10 (MDI[3]+)
unnamed: J1.8, U3.11 (MDI[3]-)
unnamed: R22.1, U3.39 (RSET)
unnamed: R25.1, R26.1, U3.34 (LED0/PHY_AD0)
unnamed: R27.1, R28.1, U3.35 (LED1/PHY_AD1)
unnamed: J1.1, U3.1 (MDI[0]+)
unnamed: J1.2, U3.2 (MDI[0]-)
unnamed: J1.3, U3.4 (MDI[1]+)
unnamed: J1.14 (LED-), R30.1
unnamed: J1.11 (LED+), R31.1
unnamed: R1.1, U1.1 (~SHDN)
unnamed: R4.1, R5.2, U1.5 (VADJ)
unnamed: GS1.1 (G1), J1.9 (VCC)
unnamed: R8.2, R14.2, U3.14 (RXD0/SELRGV)
unnamed: R11.2, R20.2, U3.18 (RXD3/AN1)
unnamed: R10.2, R18.2, U3.17 (RXD2/AN0)
unnamed: R9.2, R17.2, U3.16 (RXD1/TXDLY)
unnamed: R12.2, R15.1, U3.13 (RXCTL/PHY_AD)
unnamed: C19.1, R13.2, U3.19 (RXC)
unnamed: C21.1, C22.1, R21.1, U3.28 (DVDD10), U3.36 (DVDD10)

Notes on the sheet:
VCC1V0
ETH MAC ADDRESS

Board: 4 copper layers, 57.1 x 83.8 mm, 70 parts (23 on the bottom side), 54 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; MH-4MM

## Commit log

2015-02-08 Initial version.
2015-02-08 Converting to pmod connector.
2015-02-08 Renaming SP6N02RTL8211EGigabitEthernetExpansionModule to pmod-rgmii-RTL8211E-module.
2015-02-08 Adding a .gitignore file.

Notices in the files:
SP6N02RTL8211EGigabitEthernetExpansionModule.kicad_pcb:
License: CC BY-SA
